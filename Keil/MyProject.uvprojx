# Keil uVision project MyProject.uvprojx, settings and files
target MySample (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MyProject +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: ..\Source\Application;..\Source\Application\HMI;..\Source\Application\language;..\Source\Driver;..\Source\BSP;..\Source\STM32F4xx;..\Source\STM32F4xx\Core;..\Source\STM32F4xx\StdLib\inc;..\Source\STemWIN532;..\Source\STemWIN532\inc;..\Source\FreeRTOS900\include;..\Source\FreeRTOS900\portable;..\Source\FreeRTOS900\config;..\Source\Application\bmp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Source/Application/: main.c handshake.c panel.c selftest.c
  group App\HMI
    ../Source/Application/HMI/: hmi.c
    ../Source/Application/hmi/: hmi_switch.c hmi_maintain.c hmi_work.c hmi_work_welcome.c hmi_work_not.c hmi_work_menu.c
  group App\language
    ../Source/Application/language/: language.c
  group App\resource
    ../Source/Application/bmp/: resource.c
  group Driver
    ../Source/Driver/: drv_key.c drv_led.c drv_beep.c drv_lcd.c drv_touch.c
  group BSP
    ../Source/BSP/: bsp_led.c bsp_lcd.c bsp_touch.c bsp_delay.c bsp_beep.c
  group STemWIN
    ../Source/STemWIN532/: GUIDRV_Template.c GUIConf.c LCDConf.c GUI_X_FreeRTOS.c STemWin532_CM4_OS_Keil.lib
  group FreeRTOS\Core
    ../Source/FreeRTOS900/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS\Port
    ../Source/FreeRTOS900/portable/: heap_4.c port.c
  group STM32F4xx
    ../Source/STM32F4xx/: stm32f4xx_it.c system_stm32f4xx.c
  group STM32F4xx\StdLib
    ../Source/STM32F4xx/StdLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32F4xx\Core
    ../Source/STM32F4xx/Core/: startup_stm32f40_41xxx.s
